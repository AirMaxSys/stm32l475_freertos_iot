# Keil uVision project stm32l475_freertos_iot.uvprojx, settings and files
target stm32l475_freertos_iot (6160000::V6.16::ARMCLANG)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32l475_freertos_iot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=4
  c define: USE_HAL_DRIVER,STM32L475xx,WICED_DISABLE_BOOTLOADER,_ARMCC_VERSION,NDEBUG
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\Drivers\CMSIS\RTOS2\Include;..\Config;..\BSP;..\BSP\gui;..\BSP\lvgl_layer;..\Thirdparty\FreeRTOS\FreeRTOS-Kernel\include;..\Thirdparty\FreeRTOS\FreeRTOS-Kernel\source\portable\GCC\ARM_CM4F;..\Thirdparty\lvgl-v8.0.0;..\Thirdparty\lwip-STABLE-2_1_2_RELEASE\src\include\;..\Thirdparty\lwip-STABLE-2_1_2_RELEASE\src\include\lwip;..\Thirdparty\wifi\WICED\network\LwIP\WWD;..\Thirdparty\wifi\WICED\network\LwIP\WWD\FreeRTOS;..\Thirdparty\wifi\WICED\WWD\include;..\Thirdparty\wifi\WICED\platform\include;..\Thirdparty\wifi\WICED\platform\MCU;..\Thirdparty\wifi\WICED\platform\MCU\STM32L4xx;..\Thirdparty\wifi\WICED\platform\MCU\STM32L4xx\peripherals;..\Thirdparty\wifi\WICED\platform\MCU\STM32L4xx\WAF;..\Thirdparty\wifi\WICED\platform\ARM_CM4;..\Thirdparty\wifi\WICED\RTOS;..\Thirdparty\wifi\WICED\RTOS\FreeRTOS\WWD\ARM_CM3;..\Thirdparty\wifi\WICED\RTOS\FreeRTOS\WWD;..\Thirdparty\wifi\WICED\RTOS\FreeRTOS\WICED;..\Thirdparty\wifi\WICED\internal;..\Thirdparty\wifi\WICED\WPL\include;..\Thirdparty\wifi\WICED\WPL\core\include;..\Thirdparty\wifi\WICED\include;..\Thirdparty\wifi\WICED\security\BESL\include;..\Thirdparty\wifi\WICED\security\BESL\crypto_internal;..\Thirdparty\wifi\WICED\security\BESL\mbedtls_open\include;..\Thirdparty\wifi\WICED\LIB\utilities\ring_buffer;..\Thirdparty\wifi\WICED\LIB\utilities\TLV;..\Thirdparty\wifi\WICED\WWD;..\Thirdparty\wifi\WICED\WWD\internal\bus_protocols;..\Thirdparty\wifi\WICED\WWD\internal\bus_protocols\SDIO;..\Thirdparty\wifi\WICED\WWD\internal\bus_protocols\chips;..\Thirdparty\wifi\WICED\WWD\internal\chips\43362;..\Thirdparty\wifi\WICED;..\Thirdparty\wifi\WICED\LIB\utilities\crc;..\Thirdparty\wifi\WICED\LIB\utilities\linked_list;..\Thirdparty\wifi\WICED\security\BESL\host\WICED;..\Thirdparty\wifi\WICED\network\LwIP\WICED;..\Thirdparty\wifi\WICED\platform\ARM_CM4\CMSIS;..\Thirdparty\mqtt\port;..\Thirdparty\mqtt\paho.mqtt.embedded-c-1.1.0\MQTTPacket\src;..\Thirdparty\mqtt\paho.mqtt.embedded-c-1.1.0\MQTTClient-C\src;..\Thirdparty\mqtt\paho.mqtt.embedded-c-1.1.0\MQTTClient-C\src\FreeRTOS;..\BSP\fatfs_lowlevel_drv;..\Thirdparty\fatfs\source;..\Thirdparty\FreeRTOS\FreeRTOS-Kernel\include\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_qspi.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_adc.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/RTOS2/Source/: os_systick.c
    ../Core/Src/: system_stm32l4xx.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c quadspi.c sai.c sdmmc.c spi.c usart.c usb_otg.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c adc.c
  group BSP
    ../BSP/: aht10.c btn.c i2c_soft.c st7789v2.c led.c
    ../BSP/lvgl_layer/: btn_lvgl_layer.c tft_lvgl_layer.c fs_lvgl_layer.c
    ../BSP/gui/: gui.c
    ../BSP/fatfs_lowlevel_drv/: mmc.c
  group Config
    ../Config/: FreeRTOSConfig.h proj_config.h
  group Demos
    ../Demo/: tcp_socket_server.c wiced_scan_demo.c mqtt_pub_th_sensor.c iot_demo.c
  group FreeRTOS/Kernel
    ../Thirdparty/FreeRTOS/FreeRTOS-Kernel/include/config/: FreeRTOSConfig.h
    ../Thirdparty/FreeRTOS/FreeRTOS-Kernel/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Thirdparty/FreeRTOS/FreeRTOS-Kernel/source/portable/MemMang/: heap_4.c
    ../Thirdparty/FreeRTOS/FreeRTOS-Kernel/source/portable/GCC/ARM_CM4F/: port.c
  group LVGL
    ../Thirdparty/lvgl-v8.0.0/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Thirdparty/lvgl-v8.0.0/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Thirdparty/lvgl-v8.0.0/src/extra/: lv_extra.c
    ../Thirdparty/lvgl-v8.0.0/src/extra/themes/default/: lv_theme_default.c
    ../Thirdparty/lvgl-v8.0.0/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_48.c
    ../Thirdparty/lvgl-v8.0.0/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Thirdparty/lvgl-v8.0.0/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Thirdparty/lvgl-v8.0.0/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LWIP
    ../Thirdparty/wifi/WICED/network/LwIP/WWD/FreeRTOS/: sys_arch.c
    ../Thirdparty/lwip-STABLE-2_1_2_RELEASE/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Thirdparty/lwip-STABLE-2_1_2_RELEASE/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Thirdparty/lwip-STABLE-2_1_2_RELEASE/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Thirdparty/lwip-STABLE-2_1_2_RELEASE/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Thirdparty/lwip-STABLE-2_1_2_RELEASE/src/netif/: ethernet.c lowpan6.c
  group WIFI/WICED
    ../Thirdparty/wifi/WICED/platform/MCU/STM32L4xx/WWD/: wwd_platform.c
    ../Thirdparty/wifi/WICED/RTOS/FreeRTOS/WWD/: wwd_rtos.c
    ../Thirdparty/wifi/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c
    ../Thirdparty/wifi/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c
    ../Thirdparty/wifi/WICED/WWD/internal/chips/43362/: wwd_ap.c wwd_chip_specific_functions.c
    ../Thirdparty/wifi/WICED/WWD/internal/: wwd_ap_common.c wwd_debug.c wwd_eapol.c wwd_internal.c wwd_logging.c wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_thread.c wwd_thread_internal.c wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_sleep.c
    ../Thirdparty/wifi/WICED/platform/MCU/: wwd_platform_separate_mcu.c wwd_resources.c
    ../Thirdparty/wifi/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_network.c
    ../Thirdparty/wifi/WICED/LIB/utilities/TLV/: tlv.c
    ../Thirdparty/wifi/WICED/LIB/utilities/ring_buffer/: ring_buffer.c
    ../Thirdparty/wifi/WICED/internal/: wiced_crypto.c wiced_lib.c
  group WIFI/WICED/Platform
    ../Thirdparty/wifi/WICED/platform/MCU/STM32L4xx/WWD/: wwd_SDIO.c
    ../Thirdparty/wifi/WICED/platform/ARM_CM4/: host_cm4.c
    ../Thirdparty/wifi/WICED/platform/MCU/STM32L4xx/: platform_init.c
    ../Thirdparty/wifi/WICED/platform/MCU/STM32L4xx/peripherals/: platform_gpio.c platform_uart.c platform_mcu_powersave.c
    ../Thirdparty/wifi/WICED/RTOS/FreeRTOS/WWD/ARM_CM3/: low_level_init.c
    ../Thirdparty/wifi/WICED/LIB/stm32_hal_peripherals/gpio/: gpio.c
    ../Thirdparty/wifi/WICED/platform/MCU/: platform_resource.c
    ../Thirdparty/wifi/port/: pandora_platform.c
  group MQTT/paho-mqtt
    ../Thirdparty/mqtt/paho.mqtt.embedded-c-1.1.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../Thirdparty/mqtt/paho.mqtt.embedded-c-1.1.0/MQTTClient-C/src/: MQTTClient.c
  group MQTT/port
    ../Thirdparty/mqtt/port/: MQTTFreeRTOS.c
  group Fatfs
    ../Thirdparty/fatfs/source/: diskio.c ff.c ffunicode.c
  group Test
    ../Test/: mqtt_clinet_test.c fatfs_test.c lcd_driver_test.c
software components: CMSIS:CORE 5.3.0
